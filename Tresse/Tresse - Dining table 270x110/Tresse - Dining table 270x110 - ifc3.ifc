Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-06T17:54:49
Made in: SketchUp Pro 2015

# IfcProject, Default Project
Description: Description of Default Project

# IfcSite, Default Site
Description: Description of Default Site; RefLatitude: 24, 28, 0; RefLongitude: 54, 25, 0; RefElevation: 10 mm

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Building Storey
In: Default Building
Description: Description of Default Building Storey; Elevation: 0 mm

# IfcBuildingElementProxy (56)
In: Default Building Storey
Description: Description of Object
Name
Componente#1
Componente#2
Componente#3
Componente#4
Componente#5
Componente#6
Componente#7
Componente#11
Componente#8
Componente#9
Componente#10
Componente#12
Componente#13
Componente#14
Componente#15
Componente#16
Componente#17
Componente#18
Componente#19
Componente#20
Componente#30
Componente#21
Componente#22
Componente#23
Componente#24
Componente#25
Componente#26
Componente#27
Componente#28
Componente#29
Componente#31
Componente#32
Componente#33
Componente#50
Componente#51
Componente#52
Componente#53
Componente#54
Componente#55
Componente#56
Componente#34
Componente#35
Componente#36
Componente#37
Componente#38
Componente#39
Componente#40
Componente#41
Componente#42
Componente#43
Componente#44
Componente#45
Componente#46
Componente#47
Componente#48
Componente#49
