Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Tresse - Dining table 270x110 - ifc4.ifc
Time: 2023-10-06T17:55:01
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (56)
Name
 | Componente#1 - Description: Componente#1; ObjectType: SketchupComponentInstance
 | Componente#2 - Description: Componente#2; ObjectType: SketchupComponentInstance
 | Componente#3 - Description: Componente#3; ObjectType: SketchupComponentInstance
 | Componente#4 - Description: Componente#4; ObjectType: SketchupComponentInstance
 | Componente#5 - Description: Componente#5; ObjectType: SketchupComponentInstance
 | Componente#6 - Description: Componente#6; ObjectType: SketchupComponentInstance
 | Componente#7 - Description: Componente#7; ObjectType: SketchupComponentInstance
 | Componente#11 - Description: Componente#11; ObjectType: SketchupComponentInstance
 | Componente#8 - Description: Componente#8; ObjectType: SketchupComponentInstance
 | Componente#9 - Description: Componente#9; ObjectType: SketchupComponentInstance
 | Componente#10 - Description: Componente#10; ObjectType: SketchupComponentInstance
 | Componente#12 - Description: Componente#12; ObjectType: SketchupComponentInstance
 | Componente#13 - Description: Componente#13; ObjectType: SketchupComponentInstance
 | Componente#14 - Description: Componente#14; ObjectType: SketchupComponentInstance
 | Componente#15 - Description: Componente#15; ObjectType: SketchupComponentInstance
 | Componente#16 - Description: Componente#16; ObjectType: SketchupComponentInstance
 | Componente#17 - Description: Componente#17; ObjectType: SketchupComponentInstance
 | Componente#18 - Description: Componente#18; ObjectType: SketchupComponentInstance
 | Componente#19 - Description: Componente#19; ObjectType: SketchupComponentInstance
 | Componente#20 - Description: Componente#20; ObjectType: SketchupComponentInstance
 | Componente#30 - Description: Componente#30; ObjectType: SketchupComponentInstance
 | Componente#21 - Description: Componente#21; ObjectType: SketchupComponentInstance
 | Componente#22 - Description: Componente#22; ObjectType: SketchupComponentInstance
 | Componente#23 - Description: Componente#23; ObjectType: SketchupComponentInstance
 | Componente#24 - Description: Componente#24; ObjectType: SketchupComponentInstance
 | Componente#25 - Description: Componente#25; ObjectType: SketchupComponentInstance
 | Componente#26 - Description: Componente#26; ObjectType: SketchupComponentInstance
 | Componente#27 - Description: Componente#27; ObjectType: SketchupComponentInstance
 | Componente#28 - Description: Componente#28; ObjectType: SketchupComponentInstance
 | Componente#29 - Description: Componente#29; ObjectType: SketchupComponentInstance
 | Componente#31 - Description: Componente#31; ObjectType: SketchupComponentInstance
 | Componente#32 - Description: Componente#32; ObjectType: SketchupComponentInstance
 | Componente#33 - Description: Componente#33; ObjectType: SketchupComponentInstance
 | Componente#50 - Description: Componente#50; ObjectType: SketchupComponentInstance
 | Componente#51 - Description: Componente#51; ObjectType: SketchupComponentInstance
 | Componente#52 - Description: Componente#52; ObjectType: SketchupComponentInstance
 | Componente#53 - Description: Componente#53; ObjectType: SketchupComponentInstance
 | Componente#54 - Description: Componente#54; ObjectType: SketchupComponentInstance
 | Componente#55 - Description: Componente#55; ObjectType: SketchupComponentInstance
 | Componente#56 - Description: Componente#56; ObjectType: SketchupComponentInstance
 | Componente#34 - Description: Componente#34; ObjectType: SketchupComponentInstance
 | Componente#35 - Description: Componente#35; ObjectType: SketchupComponentInstance
 | Componente#36 - Description: Componente#36; ObjectType: SketchupComponentInstance
 | Componente#37 - Description: Componente#37; ObjectType: SketchupComponentInstance
 | Componente#38 - Description: Componente#38; ObjectType: SketchupComponentInstance
 | Componente#39 - Description: Componente#39; ObjectType: SketchupComponentInstance
 | Componente#40 - Description: Componente#40; ObjectType: SketchupComponentInstance
 | Componente#41 - Description: Componente#41; ObjectType: SketchupComponentInstance
 | Componente#42 - Description: Componente#42; ObjectType: SketchupComponentInstance
 | Componente#43 - Description: Componente#43; ObjectType: SketchupComponentInstance
 | Componente#44 - Description: Componente#44; ObjectType: SketchupComponentInstance
 | Componente#45 - Description: Componente#45; ObjectType: SketchupComponentInstance
 | Componente#46 - Description: Componente#46; ObjectType: SketchupComponentInstance
 | Componente#47 - Description: Componente#47; ObjectType: SketchupComponentInstance
 | Componente#48 - Description: Componente#48; ObjectType: SketchupComponentInstance
 | Componente#49 - Description: Componente#49; ObjectType: SketchupComponentInstance
